# Keil uVision project opl1000_aliyun.uvprojx, settings and files
target aliyun_sdk (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: opl1000_aliyun +hex (library)
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: OPL1000_APS __noSIMULATOR__ __BLE__ __LE_HOST_USE_CMD__ __LWIP_TASK__ __WPA_SUPPLICANT__ __noHW_CRYPTO_ENGINE__ __WIFI_MAC_TASK__ __NL1000_An__ __PMP_ENABLE__ __PMP_REGION__ __HEAP_REGION__ noLWIP_DYNAMIC_DEBUG_ENABLE __AT_CMD_TASK__ MBEDTLS_CONFIG_FILE="<config-opl-default.h>" ALI_BLE_WIFI_PROVISION MBEDTLS_PLATFORM_MEMORY
  c misc: --preinclude=sys_common.h --diag_suppress=1295  --diag_suppress=1 --diag_suppress=47
  c include: ..\..\..\..\APS\FreeRtos\Source\include;..\..\..\..\APS\FreeRtos\Source\portable\Keil\ARM_CM3;..\..\..\..\APS\driver\CMSIS\Include;..\..\..\..\APS\driver\CMSIS\Device\opl1000\Include;..\..\..\..\APS\driver\chip;..\..\..\..\APS\driver\chip\opl1000\securityipdriver;..\..\..\..\APS\driver\chip\opl1000\securityipdriver\lib;..\..\..\..\APS\driver\chip\opl1000\hal_auxadc;..\..\..\..\APS\driver\chip\opl1000\hal_system;..\..\..\..\APS\driver\chip\opl1000\hal_patch;..\..\..\..\APS\driver\chip\opl1000\hal_uart;..\..\..\..\APS\driver\chip\opl1000\hal_spi;..\..\..\..\APS\driver\chip\opl1000\hal_vic;..\..\..\..\APS\driver\chip\opl1000\hal_dbg_uart;..\..\..\..\APS\driver\chip\opl1000\hal_wdt;..\..\..\..\APS\driver\chip\opl1000\hal_dma;..\..\..\..\APS\driver\chip\opl1000\hal_tmr;..\..\..\..\APS\driver\chip\opl1000\hal_tick;..\..\..\..\APS\driver\chip\opl1000\hal_pwm;..\..\..\..\APS\driver\chip\opl1000\hal_i2c;..\..\..\..\APS\project\opl1000\include;..\..\..\..\APS\project\common;..\..\..\..\APS\middleware\netlink;..\..\..\..\APS\middleware\netlink\cli;..\..\..\..\APS\middleware\netlink\msg;..\..\..\..\APS\middleware\netlink\data_flow;..\..\..\..\APS\middleware\netlink\wifi_controller_layer;..\..\..\..\APS\middleware\netlink\ble_controller_layer\inc;..\..\..\..\APS\middleware\netlink\le_stack;..\..\..\..\APS\middleware\netlink\at;..\..\..\..\APS\middleware\netlink\iperf\inc;..\..\..\..\APS\middleware\netlink\controller_task;..\..\..\..\APS\middleware\netlink\ps_task;..\..\..\..\APS\middleware\netlink\diag_task;..\..\..\..\APS\middleware\netlink\wifi_mac;..\..\..\..\APS\apps\le_app\pts_app;..\..\..\..\APS\apps\le_app\mtc_app;..\..\..\..\APS\apps\le_app\cmd_app;..\..\..\..\APS\middleware\third_party\lwip-2.0.3\lwip\src\include;..\..\..\..\APS\middleware\third_party\lwip-2.0.3\ports\freertos\include;..\..\..\..\APS\middleware\third_party\lwip-2.0.3\ports\freertos\netif;..\..\..\..\APS\middleware\third_party\lwip-2.0.3\ports\rom_if;..\..\..\..\APS\middleware\third_party\lwip-2.0.3\;..\..\..\..\APS\middleware\third_party\tinycrypt\include;..\..\..\..\APS\middleware\third_party\mbedtls\configs;..\..\..\..\APS\middleware\third_party\mbedtls\include;..\..\..\..\APS\middleware\third_party\mbedtls\port\include;..\..\..\..\APS\project\opl1000\boot_sequence;..\..\..\..\APS\project\opl1000\startup;..\..\..\driver\chip\opl1000\hal_system;..\..\..\middleware\netlink\diag_task;..\..\..\..\APS\middleware\netlink\mw_fim;.\src\coap;.\src\coap\CoAPPacket;.\src\coap\server;.\src\dev_bind;.\src\dev_bind\impl;.\src\dev_bind\impl\awss_reset;.\src\dev_bind\impl\os;.\src\dev_model;.\src\dev_model\client;.\src\dev_model\deprecated;.\src\dev_model\alcs;.\src\dev_model\server;.\src\dev_sign;.\src\infra;.\src\kv\include;.\src\kv\include\aos;.\src\mqtt;.\src\mqtt\impl;.\src\wifi_provision;.\src\wifi_provision\frameworks;.\src\wifi_provision\frameworks\aplist;.\src\wifi_provision\frameworks\ieee80211;.\src\wifi_provision\frameworks\statics;.\src\wifi_provision\frameworks\utils;.\src\wifi_provision\zero_config;.\src\wifi_provision\frameworks\statics;.\wrappers;.\src\dynamic_register;.\src\ota;.\certs;..\..\..\..\APS\middleware\netlink\mw_ota
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xc0000
  memory RVCT9: RAM 0x400000 size 0x50000
  group ali_src_coap_CoAPPacket
    ./src/coap/CoAPPacket/: CoAPDeserialize_common.c CoAPMessage_common.c CoAPSerialize_common.c
  group ali_src_coap_server
    ./src/coap/server/: CoAPExport.c CoAPMessage.c CoAPNetwork.c CoAPObserve.c CoAPPlatform.c CoAPResource.c CoAPServer.c
  group ali_src_dev_bind_impl
    ./src/dev_bind/impl/: awss_bind.c awss_bind_statis.c awss_cmp_coap.c awss_cmp_mqtt.c awss_event.c awss_info.c awss_notify.c awss_packet.c awss_report.c awss_timer.c passwd.c
  group ali_src_dev_bind_impl_awss_reset
    ./src/dev_bind/impl/awss_reset/: awss_dev_reset.c
  group ali_src_dev_bind_impl_os
    ./src/dev_bind/impl/os/: os_misc.c
  group ali_src_dev_sign
    ./src/dev_sign/: dev_sign_mqtt.c
  group ali_src_infra
    ./src/infra/: infra_aes.c infra_cjson.c infra_compat.c infra_defs.c infra_httpc.c infra_json_parser.c infra_log.c infra_md5.c infra_mem_stats.c infra_net.c infra_preauth.c infra_prt_nwk_payload.c infra_report.c infra_sha1.c infra_sha256.c infra_string.c infra_timer.c redirect_region.c
  group ali_src_mqtt
    ./src/mqtt/: mqtt_api.c
  group ali_src_mqtt_impl
    ./src/mqtt/impl/: iotx_mqtt_client.c MQTTConnectClient.c MQTTDeserializePublish.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c
  group ali_wrappers_os_freertos
    ./wrappers/os/freertos/: HAL_OS_Freertos.c HAL_TCP_FreeRTOS.c HAL_UDP_FreeRTOS.c HAL_Crypt_freertos.c
  group ali_src_dev_model
    ./src/dev_model/: dm_api.c dm_ipc.c dm_log_report.c dm_manager.c dm_message.c dm_message_cache.c dm_msg_process.c dm_opt.c dm_utils.c impl_linkkit.c iotx_cm.c iotx_cm_coap.c iotx_cm_mqtt.c dm_ota.c dm_cota.c dm_fota.c
  group ali_src_dev_model_client
    ./src/dev_model/client/: dm_client.c dm_client_adapter.c
  group ali_src_dev_model_example
    ./src/dev_model/examples/: cJSON.c
  group ali_src_dev_model_alcs
    ./src/dev_model/alcs/: alcs_adapter.c alcs_api.c alcs_base64.c alcs_client.c alcs_coap.c alcs_localsetup.c alcs_mqtt.c alcs_server.c
  group ali_src_wifi_provision_frameworks
    ./src/wifi_provision/frameworks/statics/: awss_statis.c
  group ali_src_kv
    ./src/kv/: aos_freertos.c kvmgr.c
  group ali_src_ota
    ./src/ota/: iotx_ota.c ota_coap.c ota_fetch.c ota_lib.c ota_mqtt.c
  group ali_src_wrappers_tls
    ./wrappers/tls/: HAL_DTLS_mbedtls.c HAL_TLS_mbedtls.c
  group ali_certs
    ./certs/: root_ca.c
  group ali_src_dev_model_server
    ./src/dev_model/server/: dm_server.c dm_server_adapter.c
target aliyun_sdk_worldwide (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: opl1000_aliyun_worldwide +hex (library)
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: OPL1000_APS __noSIMULATOR__ __BLE__ __LE_HOST_USE_CMD__ __LWIP_TASK__ __WPA_SUPPLICANT__ __noHW_CRYPTO_ENGINE__ __WIFI_MAC_TASK__ __NL1000_An__ __PMP_ENABLE__ __PMP_REGION__ __HEAP_REGION__ noLWIP_DYNAMIC_DEBUG_ENABLE __AT_CMD_TASK__ MBEDTLS_CONFIG_FILE="<config-opl-default.h>" ALI_BLE_WIFI_PROVISION MBEDTLS_PLATFORM_MEMORY WORLDWIDE_USE
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xc0000
  memory RVCT9: RAM 0x400000 size 0x50000
